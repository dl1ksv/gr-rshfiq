<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>RS_HFIQ</value></param>
<param><key>author</key><value>Volker Schroer, dl1ksv</value></param>
<param><key>description</key><value>Small example to test the rshfiq source</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>RS-HFIQ Receiver test</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>RxFrequency</value></param>
<param><key>value</key><value>14070*1000</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>3000*1000</value></param>
<param><key>step</key><value>10000</value></param>
<param><key>stop</key><value>28800*1000</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>RxFrequency</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Spectrum Complex IQ data</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>RxFrequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label1</key><value>Spectrum I Value</value></param>
<param><key>label2</key><value>Spectrum Q Value</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rshfiq_rshfiq</key>
<param><key>id</key><value>rshfiq_rshfiq_0</value></param>
<param><key>freq</key><value>RxFrequency</value></param>
<param><key>control_device</key><value>/dev/ttyUSB0</value></param>
<param><key>audio_device_name</key><value>Device</value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rshfiq_rshfiq_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rshfiq_rshfiq_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
